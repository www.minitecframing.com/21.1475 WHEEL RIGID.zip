# Autodesk Inventor assembly: 21.1475 WHEEL RIGID
## iProperties
Created: 2007-04
Part Number: 21.1475 WHEEL RIGID
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
